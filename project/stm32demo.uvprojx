# Keil uVision project stm32demo.uvprojx, settings and files
target Robot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32demo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\cmsis;..\libraries\src;..\stm32;..\user;..\libraries\inc;..\user;..\Action;..\Hardware;..\Kinematics;..\Module;..\Robot;..\RobotFrame;..\Serial;..\Module\EMPL
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group libraries
    ../libraries/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group stm32
    ../stm32/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40_41xxx.s stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.h
  group cmsis
    ../cmsis/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Hardware
    ../Hardware/: Delay.c Delay.h OLED.c OLED.h OLED_Font.h aboard.c aboard.h
  group Action
    ../Action/: Action.c Action.h common.h GaitController.c GaitController.h
  group Robot
    ../Robot/: RobotServoController.c RobotServoController.h Ctrl_leg.c Ctrl_leg.h
  group Serial
    ../Serial/: AsrProSerial.c AsrProSerial.h BlueSerial.c BlueSerial.h Serial.c Serial.h PrintfSerial.h PrintfSerial.c
  group Kinematics
    ../Kinematics/: Mathematical.c Mathematical.h
  group Module
    ../Module/: obstacle.c obstacle.h cloud.c cloud.h buzzer.c buzzer.h
  group user
    ../user/: main.c Frame.h
